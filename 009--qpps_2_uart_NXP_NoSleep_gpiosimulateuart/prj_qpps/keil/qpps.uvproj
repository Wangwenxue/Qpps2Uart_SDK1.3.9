# Keil uVision project qpps.uvproj, settings and files
target qpps (ARM-ADS)
  device: QN9020 NXP
  cpu: IRAM(0x10008000-0x1000FFFF) IROM(0x10000000-0x10007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: qpps
  AfterMake: fromelf --bin --output ./bin/qpps.bin ./obj/qpps.axf
  c flags: Optim=4 OneElfS=1
  c misc: --C99
  c include: ..\..\src\fw;..\..\src\profiles;..\..\src\profiles\qpp;..\..\src\profiles\qpp\qpps;..\..\src\profiles\dis\diss;..\..\src\app;..\..\src\app\gap;..\..\src\app\gatt;..\..\src\app\smp;..\..\src\app\qpps;..\..\src\app\diss;..\..\src\cmsis;..\..\src\driver;..\..\src\lib;..\..\src\qnevb;..\src;..\..\src\profiles\ota\otas;..\..\src\app\otas
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
  group startup
    ../../src/startup/keil/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c App_pt.c
  group app
    ../../src/app/: app_util.c app_env.c app_printf.c app_sys.c app_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/diss/: app_diss.c app_diss_task.c
    ../../src/app/qpps/: app_qpps.c app_qpps_task.c
    ../../src/app/otas/: app_otas_task.c
  group profiles
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/dis/diss/: diss.c diss_task.c
    ../../src/profiles/qpp/qpps/: qpps.c qpps_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c wdt.c timer.c rtc.c serialflash.c gpio_uart_driver.c
  group lib
    ../../src/lib/keil/: qn9020b2_lib_peripheral.lib qn9020b4_lib_peripheral.lib
    ../../src/profiles/ota/otas/: qn_ota_b2.lib
  group qnevb
    ../../src/qnevb/: led.c button.c
  group retarget
    ../../src/retarget/: retarget.c
